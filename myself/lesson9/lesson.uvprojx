# Keil uVision project lesson.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32C031C6Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32C031xx
  c include: .\cmsis;.\user
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group cmsis
    ./cmsis/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm0.h core_cm0plus.h startup_stm32c031xx.s stm32c0xx.h stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h mpu_armv7.h cmsis_armcc.h
  group user
    ./user/: delay.c delay.h main.c
