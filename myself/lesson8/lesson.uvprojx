# Keil uVision project lesson.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32C031C6Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\cmsis;.\core
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group lesson
    ./cmsis/: startup_stm32c031xx.s stm32c031xx.h
    ./core/: main.c delay.c delay.h
